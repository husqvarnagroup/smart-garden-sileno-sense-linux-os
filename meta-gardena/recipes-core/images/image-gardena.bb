inherit image-gardena

IMAGE_TEGRAFLASH_FS_TYPE = "squashfs"
