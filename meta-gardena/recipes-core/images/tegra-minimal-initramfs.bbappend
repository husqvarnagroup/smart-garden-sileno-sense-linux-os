
TEGRA_INITRD_BASEUTILS += "e2fsprogs"
TEGRA_INITRD_BASEUTILS += "cryptsetup"
