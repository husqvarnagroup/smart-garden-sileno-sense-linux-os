
DUMMYPROVIDES = "\
    /usr/bin/env \
    /usr/bin/perl \
    libperl.so.5 \
    libperl.so.5()(64bit) \
"

