
CUDA_COMPONENTS:remove = " cuda-command-line-tools" 
