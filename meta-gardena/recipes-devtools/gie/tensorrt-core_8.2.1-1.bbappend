 
RDEPENDS:${PN}:remove = " cuda-command-line-tools-libnvtoolsext"
