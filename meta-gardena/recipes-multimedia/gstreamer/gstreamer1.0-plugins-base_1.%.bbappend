PACKAGECONFIG:remove = " pango"
