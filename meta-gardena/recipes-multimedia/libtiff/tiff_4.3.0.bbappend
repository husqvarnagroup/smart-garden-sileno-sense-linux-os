#disable jpeg for now, if you want to enable again link with libnvjpeg and not with libjpeg!
PACKAGECONFIG = "cxx zlib lzma \
                  strip-chopping extrasample-as-alpha check-ycbcr-subsampling"



